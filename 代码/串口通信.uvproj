# Keil uVision project 串口通信.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 串口通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Program Files (x86)\Keil\C51\INC
  group Source Group 1
    ./: STARTUP.A51 串口通信.c
